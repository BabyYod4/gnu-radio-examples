<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1200000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>441.12e6</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>-100000</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>25</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>cutoff_freq</key><value>5000</value></param>
<param><key>width</key><value>5000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0</value></param>
<param><key>type</key><value>ff</value></param>
<param><key>length</key><value>32</value></param>
<param><key>long_form</key><value>True</value></param>
</block>
<block>
<key>analog_agc_xx</key>
<param><key>id</key><value>analog_agc_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>rate</key><value>1e-1</value></param>
<param><key>reference</key><value>0.02</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>65536</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>25</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>50</value></param>
<param><key>num_steps</key><value>125</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>freq - 100000</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>samp_rate / 25</value></param>
<param><key>baseband_freq</key><value>freq - 100000</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>48000</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>corr</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-100</value></param>
<param><key>max</key><value>100</value></param>
<param><key>num_steps</key><value>200</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value></value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>freq0</key><value>freq - 100000</value></param>
<param><key>corr0</key><value>corr</value></param>
<param><key>gain_mode0</key><value>0</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>bb_gain0</key><value>20</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>am</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>wxgui_fftsink2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>dc_blocker_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>analog_agc_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc_xx_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc_xx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
